Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2023-10-21T20:01:02
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20191106_1200(x64) - Exporter 20.2.1.1 - Alternate UI 20.2.1.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Sat Oct 21 20:01:02 2023 * Host: DESKTOP-JLKK7TQ * Database: C:\Users\vladb\AppData\Local\Temp\00bcdd55-e729-4a74-9953-da3241b926e8\5f0b74ab-272a-41bc-b1ce-692a592e15e4\ifc * Database version: 5507 * Database creation date: Sat Oct 21 20:01:00 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Sat Oct 21 20:01:01 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Sat Oct 21 20:01:01 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1014F-105 Washbasin faucet with washing machine valve, 1014F-105(2023):1014F-105 Washbasin faucet with washing machine valve:381866
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - FaucetNominalDepth: 173 mm; FaucetNominalHeight: 163 mm; FaucetNominalWidth: 54 mm; HandShowerNominalDepth: 64.3 mm; HandShowerNominalHeight: 296.7 mm; HandShowerNominalWidth: 49.3 mm; InletConnectionSize: 10 mm
Type - General - Author: BIMStone; BIMObjectName: 1014F-105(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: Washbasin faucet with washing machine valve and Bidetta hand shower; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 01/06/2023
Type - Green Building Properties - CO2 Emissions (A1-A3): 12.1; CO2 Emissions (A4): 0.34; CO2 Emissions (B7): 1297.8; CO2 Emissions (C2): 0.02; CO2 Emissions (C3): 0.02; CO2 Emissions (C4): 0.09; CO2 Emissions (D): -8.61; EAN Number: 6414150098802; EN Standard: EN 817; ETIM Class Number: EC011431 Kitchen mixing tap; LVI Number: 6110357; Noise Class: I (ISO 3822); Sales Package dimensions (LxWxH): 590 x 290 x 65; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/1014F-105; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL Environmental Product Declaration EPD: http://www.oras.com/fileadmin/resources/184523_EPD_Washbasin faucet.pdf; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/182882_1014F-105_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL UWL: http://static.oras.com/UWL/1014F-105
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1014F-105; 3D View: https://static.oras.com/AR/1014F-105; Catalog Drawing URL: http://static.oras.com/catdrw/1014F-105; Dimension Drawing URL: http://static.oras.com/dimdrw/1014F-105; FDV Document URL: http://www.oras.com/datasheet/1014F-105/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1014F-105; Group: Washbasin faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1014F-105; Interactive AR View URL: https://static.oras.com/AR/1014F-105; Long Marketing: Washbasin faucet with washing machine valve and Bidetta hand shower. Swivel spout and aerator. Spout’s swing angle is factory preset at 120° (can be limited to 40°-80°). Washing machine valve for cold water. There are also in-built limitation options for water temperature and maximum flow-rate.; Manufacturer: Oras; Market: International;Finland;Sweden;Poland;Russia;Estonia;Lithuania;Latvia;Ukraine; Mobile Product Information URL: http://mpi.oras.com/1014F-105; Model: 1014F-105 Washbasin faucet with washing machine valve; Name_en: 1014F-105 Washbasin faucet with washing machine valve; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1014F-105; Product Family: Oras Safira Eco; Product Image URL: http://static.oras.com/image/1014F-105; Product URL: http://static.oras.com/1014F-105; Spare-Part Information URL: http://static.oras.com/sp/1014F-105; Technical DataSheet URL: http://www.oras.com/datasheet/1014F-105/en; Type Name: 1014F-105 Washbasin faucet with washing machine valve; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Aerator: Standard aerator; Connection: Flexible inlet pipes; Connection Size: G3/8; Flow Rate At 300kPa With Flow Controller: 0.00247203 m3/s; Hand Shower: Bidetta hand shower; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 40 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Shower Parts: Hand shower;Shower holder; Spout Projection: 133 mm; Spout Swivel Range: 120° (40°/80°); Spout Type: Swivel spout;Swivel range limiting option;Profile construction; Surface treatment: Chrome; Temperature: Temperature limiter; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50-1000 kPa
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1014F-105(2023); Features: Single-lever;Bidetta; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1014F-105; Name: 1014F-105 Washbasin faucet with washing machine valve; ReplacementCost: n/a; Shape: Sculptured; Size: Faucet:55x175x165 mm / Hand shower: 45x70x285 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Type - Pset_ValveTypeCommon - ValvePattern: n/a; ValveOperation: n/a; ValveMechanism: n/a; FlowCoefficient: 0; CloseOffRating: 0 Pa
Type - Pset_ValveTypeFaucet - Finish: Polished
Pset_DistributionFlowElementCommon - Reference: 1014F-105 Washbasin faucet with washing machine valve; sets with these values: 2
Pset_ElementShading - Color: Chrome
Pset_ManufacturerOccurrence - BarCode: n/a; SerialNumber: n/a
Pset_ManufacturerTypeInformation - ModelReference: 1014F-105; Manufacturer: Oras
Pset_ProductRequirements - Name: 1014F-105 Washbasin faucet with washing machine valve; Category: Plumbing Fixtures
Constraints - DistanceX-Axis: 100 mm; DistanceY-Axis: 100 mm; Elevation from Level: 0 mm; FaucetDefaultElevation: 900 mm; HandShowerDefaultElevation: 900 mm; Hand Shower Visibility: yes; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0843119 m2; Volume: 0.00246768 m3
Identity Data - Mark: 11
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 1014F-105(2023): 1014F-105 Washbasin faucet with washing machine valve; Family and Type: 1014F-105(2023): 1014F-105 Washbasin faucet with washing machine valve; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1014F-105(2023): 1014F-105 Washbasin faucet with washing machine valve; Type Id: 1014F-105(2023): 1014F-105 Washbasin faucet with washing machine valve; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
